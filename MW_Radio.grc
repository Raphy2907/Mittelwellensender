options:
  parameters:
    generate_options: no_gui
    id: MW_Radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: samp_rate_hf
  id: variable
  parameters:
    value: samp_rate_if*8
  states: {}
- name: samp_rate_if
  id: variable
  parameters:
    value: samp_rate*20
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '90000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_if
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '110000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_if
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '130000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_if
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '150000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_if
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '815000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_hf
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1000000'
    low_cutoff_freq: '875000'
    samp_rate: samp_rate_hf
    type: fir_filter_fff
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5004'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5006'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5008'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_2
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5010'
    src_zeros: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_2, '0', blocks_multiply_xx_0_2, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', rational_resampler_xxx_0_1, '0']
- [blocks_add_const_vxx_0_2, '0', rational_resampler_xxx_0_2, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_char_0, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_2, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_xx_1, '0', band_pass_filter_0, '0']
- [network_udp_source_0, '0', blocks_add_const_vxx_0, '0']
- [network_udp_source_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [network_udp_source_0_1, '0', blocks_add_const_vxx_0_1, '0']
- [network_udp_source_0_2, '0', blocks_add_const_vxx_0_2, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_xx_0_1, '0']
- [rational_resampler_xxx_0_2, '0', blocks_multiply_xx_0_2, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_2, '0', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
